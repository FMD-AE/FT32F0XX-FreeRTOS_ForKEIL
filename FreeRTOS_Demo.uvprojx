# Keil uVision project FreeRTOS_Demo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: FT32F072R8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Demo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Source\Driver\inc;.\Source\FreeRTOS\include;.\Source\Tasks\inc;.\Source\Tk_Lib;.\Source\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Source/User/src/: ft32f0xx_it.c main.c
  group Driver
    ./Source/Driver/src/: board.c Peripheral.c
  group Tasks
    ./Source/Tasks/src/: HighProTask.c IdleTask.c InitTask.c LowProTask.c TaskManager.c
  group TK_Lib
    ./Source/Tk_Lib/: TKlib.lib
  group FreeRTOS
    ./Source/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./Source/FreeRTOS/portable/: heap_4.c port.c
software components: CMSIS:CORE 5.5.0, Device:FT32Driver:ADC 1.0.1, Device:FT32Driver:COMMON 1.0.1, Device:FT32Driver:COMP 1.0.1, Device:FT32Driver:CRC 1.0.1, Device:FT32Driver:CRS 1.0.1, Device:FT32Driver:DAC 1.0.1, Device:FT32Driver:DEBUG 1.0.1, Device:FT32Driver:DMA 1.0.1, Device:FT32Driver:EXTI 1.0.1, Device:FT32Driver:FLASH 1.0.1, Device:FT32Driver:GPIO 1.0.1, Device:FT32Driver:I2C 1.0.1, Device:FT32Driver:IWDG 1.0.1, Device:FT32Driver:MISC 1.0.1, Device:FT32Driver:OPA 1.0.1, Device:FT32Driver:PWR 1.0.1, Device:FT32Driver:RCC 1.0.1, Device:FT32Driver:RTC 1.0.1, Device:FT32Driver:SPI 1.0.1, Device:FT32Driver:SYSCFG 1.0.1, Device:FT32Driver:TIM 1.0.1, Device:FT32Driver:USART 1.0.1, Device:FT32Driver:WWDG 1.0.1, Device:Startup 1.0.1
